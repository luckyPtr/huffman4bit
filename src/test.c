#include "stdio.h"
#include "huffman4bit.h"
#include <string.h>


unsigned char test_data[] =
{
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0x7F, 0x30, 0x3E, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0x7F, 0x30, 0x3E, 0xFF, 0xFF, 0x03, 0x60, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x00, 0x03, 
	0x60, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x00, 0x03, 0x60, 0x00, 0x70, 0xF0, 0x07, 0x07, 0x00, 0x03, 0x60, 0xFC, 0x71, 0x3E, 0x3E, 0xC7, 0x1F, 0x03, 0x60, 0xFC, 0x71, 0x3E, 0x3E, 0xC7, 0x1F, 0x03, 
	0x60, 0xFC, 0x71, 0x30, 0x06, 0xC7, 0x1F, 0x03, 0x60, 0xFC, 0x71, 0x30, 0x06, 0xC7, 0x1F, 0x03, 0x60, 0xFC, 0x71, 0x30, 0x06, 0xC7, 0x1F, 0x03, 0x60, 0xFC, 0x71, 0xC0, 0x39, 0xC7, 0x1F, 0x03, 
	0x60, 0xFC, 0x71, 0xC0, 0x39, 0xC7, 0x1F, 0x03, 0x60, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x60, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x60, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 
	0xE0, 0xFF, 0x7F, 0xCE, 0x39, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0x7F, 0xCE, 0x39, 0xFF, 0xFF, 0x03, 0xE0, 0xFF, 0x7F, 0xCE, 0x39, 0xFF, 0xFF, 0x03, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x8F, 0xFF, 0xFF, 0xC7, 0x07, 0x18, 0x00, 0xE0, 0x8F, 0xFF, 0xFF, 0xC7, 0x07, 0x18, 0x00, 0xE0, 0x8F, 0xFF, 0xFF, 0xC7, 0x07, 0x18, 0x00, 
	0x80, 0x7F, 0x80, 0x0F, 0x06, 0x3F, 0xE0, 0x03, 0x80, 0x7F, 0x80, 0x0F, 0x06, 0x3F, 0xE0, 0x03, 0x60, 0x8C, 0xFF, 0x31, 0x38, 0x07, 0xFF, 0x03, 0x60, 0x8C, 0xFF, 0x31, 0x38, 0x07, 0xFF, 0x03, 
	0x60, 0x8C, 0xFF, 0x31, 0x38, 0x07, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x31, 0x06, 0x38, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x31, 0x06, 0x38, 0xE0, 0x00, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0x38, 0x00, 0x00, 
	0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E, 0xC0, 0xF8, 0x00, 
	0xE0, 0xFF, 0x7F, 0x3E, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x7F, 0x3E, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0x7F, 0x3E, 0xFE, 0x00, 0xF8, 0x03, 0x60, 0x00, 0x70, 0x0E, 0x06, 0xC0, 0x00, 0x00, 
	0x60, 0x00, 0x70, 0x0E, 0x06, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x06, 0xC0, 0x00, 0x00, 0x60, 0xFC, 0x71, 0x3E, 0x06, 0x38, 0xE0, 0x00, 0x60, 0xFC, 0x71, 0x3E, 0x06, 0x38, 0xE0, 0x00, 
	0x60, 0xFC, 0x71, 0x30, 0x3E, 0xFF, 0xF8, 0x00, 0x60, 0xFC, 0x71, 0x30, 0x3E, 0xFF, 0xF8, 0x00, 0x60, 0xFC, 0x71, 0x30, 0x3E, 0xFF, 0xF8, 0x00, 0x60, 0xFC, 0x71, 0x0E, 0xFE, 0x38, 0x18, 0x03, 
	0x60, 0xFC, 0x71, 0x0E, 0xFE, 0x38, 0x18, 0x03, 0x60, 0x00, 0x70, 0xCE, 0x3F, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0xCE, 0x3F, 0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0xCE, 0x3F, 0xC0, 0xE0, 0x00, 
	0xE0, 0xFF, 0x7F, 0xCE, 0xF9, 0x38, 0xE0, 0x03, 0xE0, 0xFF, 0x7F, 0xCE, 0xF9, 0x38, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 
};
#include "bm_img.h"

int main(int argc, char *argv[])
{
	unsigned char output_data[2024];
	unsigned int output_len;
	unsigned char output_data1[2024];
	unsigned int output_len1;
	huffman_tree_tbl_t huffman_tree_tbl[16] = {0};

	// h4b_reset();
	// for (int i = 0; i < 50; i++)
	// {
	// 	h4b_add_array((unsigned char *)IMG_BAD_APPLE[i], 1024);
	// }
	// h4b_clustering(1);
	// h4b_create_huffman_tree(huffman_tree_tbl);

	// int total = 0;
	// for(int i = 0; i < 50; i++)
	// {
	// 	h4b_encode(IMG_BAD_APPLE[i], 1024, output_data, &output_len);
	// 	total += output_len;
	// 	h4b_decode(output_data, output_len, huffman_tree_tbl, output_data1, &output_len1);
	// 	printf("%d\n", output_len1);
	// 	if (memcmp(IMG_BAD_APPLE[i], output_data1, 1024))
	// 	{
	// 		printf("failed\n"); 
	// 	}
	// 	else
	// 	{
	// 		printf("successful\n");
	// 	}
	// 	printf("image saved percent: %f\n", (double)output_len / 1024);
	// }
	// printf("save percent: %f\n", (double)total / (50 * 1024));
	//print_added_array();

	h4b_init();	
	h4b_uint8_t *random_datas[1000] = {0};
	h4b_uint16_t random_datas_len[1000] = {0};
	for (int i = 0; i < 1000; i++)
	{
		random_datas_len[i] = (rand() % 1023) + 1;
		random_datas[i] = (h4b_uint8_t *)malloc(1024);
		for (int j = 0; j < random_datas_len[i]; j++)
		{
			random_datas[i][j] = rand() % 256;
		}
		h4b_add_array(random_datas[i], random_datas_len[i]);
	}
	h4b_clustering(1);
	h4b_create_huffman_tree(huffman_tree_tbl);
	for (int i = 0; i < 1000; i++)
	{
		h4b_encode(random_datas[i], random_datas_len[i], output_data, &output_len);
		h4b_decode(output_data, output_len, huffman_tree_tbl, output_data1, &output_len1);
		printf("%d\n", output_len1);
		if (memcmp(random_datas[i], output_data1, random_datas_len[i]))
		{
			printf("failed\n");
			break;
		}
		else
		{
			printf("successful\n");
		}
		printf("--image saved percent: %f\n", (double)output_len / random_datas_len[i]);
	}




	// for (int i = 0; i < 40; i++)
	// {
	// 	h4b_count_freq_append(IMG_BAD_APPLE[i], 1024);
	// }
	
	// h4b_create_huffman_tree(&huffman_tree_tbl);
	// h4b_encode(test_data, 1024, output_data, &output_len);
	// h4b_decode(output_data, output_len, &huffman_tree_tbl, output_data1, &output_len1);
	// if (memcmp(test_data, output_data1, 1024))
	// {
	// 	printf("failed\n");
	// }
	// else
	// {
		printf("successful\n");
	// }
	// for (int i = 0; i < 1024; i++)
	// {
	// 	printf("0x%02x, ", output_data1[i]);
	// 	if ((i + 1) % 8 == 0)printf("\n");
	// }

	// printf("\n\n\n\n\n\n");
	// for (int i = 0; i < 1024/8; i++)
	// {
	// 	printf("0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,\n");
	// }

    return 0;
}